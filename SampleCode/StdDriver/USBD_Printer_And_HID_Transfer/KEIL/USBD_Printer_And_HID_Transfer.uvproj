# Keil uVision project USBD_Printer_And_HID_Transfer.uvproj, settings and files
target USBD_Printer_And_HID_Transfer (ARM-ADS)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_Printer_And_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c include: ..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_i94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group User
    ../: readme.txt main.c ConfigSysClk.h printer_hidtrans.c printer_hidtrans_desc.c SysClk.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c usbd.c uart.c gpio.c timer.c
