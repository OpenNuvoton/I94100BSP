# Keil uVision project SYS_TrimHIRC.uvproj, settings and files
target SYS_TrimHIRC (ARM-ADS)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: SYS_TrimHIRC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\Include;..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_i94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group User
    ../: main.c hid_desc.c hid_request.c ConfigSysClk.h readme.txt SysClk.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c timer.c usbd.c
