<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_UAC_I2S_Output.ewp</path>
  </project>
  <batchBuild/>
</workspace>


