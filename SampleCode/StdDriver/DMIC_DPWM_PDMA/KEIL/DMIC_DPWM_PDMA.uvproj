# Keil uVision project DMIC_DPWM_PDMA.uvproj, settings and files
target DMIC_DPWM_PDMA (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: DMIC_DPWM_PDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I94100
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_i94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
    ./: startup_I94100.s
  group User
    ../: main.c ConfigSysClk.h readme.txt SysClk.c
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c sys.c retarget.c dmic.c dpwm.c pdma.c
