# IAR project DMIC_DPWM_PDMA.ewp, settings and files
configuration DMIC_DPWM_PDMA (ARM, debug)
  General.OGChipSelectEditMenu: I94000 series Nuvoton I94000 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\Include; ..\..\..\..\Library\Device\Nuvoton\I94100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DMIC_DPWM_PDMA.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dmic.c dpwm.c pdma.c retarget.c sys.c uart.c
  group User
    ../: ConfigSysClk.h main.c readme.txt SysClk.c
