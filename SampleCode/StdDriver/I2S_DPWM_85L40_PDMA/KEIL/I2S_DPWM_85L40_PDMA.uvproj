# Keil uVision project I2S_DPWM_85L40_PDMA.uvproj, settings and files
target I2S_DPWM_85L40_PDMA (ARM-ADS)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S_DPWM_85L40_PDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=1
  c include: ..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_I94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group User
    ../: main.c ConfigSysClk.h readme.txt SysClk.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c i2c.c i2s.c dpwm.c pdma.c
