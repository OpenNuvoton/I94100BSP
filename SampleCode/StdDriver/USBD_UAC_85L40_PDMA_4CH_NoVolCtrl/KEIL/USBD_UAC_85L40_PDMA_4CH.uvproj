# Keil uVision project USBD_UAC_85L40_PDMA_4CH.uvproj, settings and files
target USBD_UAC_85L40_PDMA_4CH (ARM-ADS)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_UAC_85L40_PDMA_4CH
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c misc: --C99
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\Device\Nuvoton\I94100;..\..\USBD_HID_Transfer
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_I94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
    ./: startup_I94100.s
  group User
    ../: main.c audio_desc.c AudioClass.c NAU85L40.c SysClk.c ConfigSysClk.h HIRC_AutoTrim.c
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c usbd.c uart.c i2c.c i2s.c pdma.c timer.c gpio.c
