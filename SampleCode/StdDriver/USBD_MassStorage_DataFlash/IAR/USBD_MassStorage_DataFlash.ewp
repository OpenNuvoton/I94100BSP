# IAR project USBD_MassStorage_DataFlash.ewp, settings and files
configuration USBD_MassStorage_DataFlash (ARM, debug)
  General.OGChipSelectEditMenu: I94000 series Nuvoton I94000 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\Include; ..\..\..\..\Library\Device\Nuvoton\I94100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_MassStorage_DataFlash.bin
  ILINK.IlinkOutputFile: USBD_MassStorage_DataFlash.out
  ILINK.IlinkIcfFile: USBD_MassStorage_DataFlash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c timer.c uart.c usbd.c
  group User
    ../: ConfigSysClk.h dataflash.c main.c massstorage.c msc_desc.c readme.txt SysClk.c usbd_bot.c usbd_scsi.c
