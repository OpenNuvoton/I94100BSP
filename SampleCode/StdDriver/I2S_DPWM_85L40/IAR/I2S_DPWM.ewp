# IAR project I2S_DPWM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: I94000 series Nuvoton I94000 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\I94100\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Device\Nuvoton\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2S_DPWM.bin
  ILINK.IlinkOutputFile: I2S_DPWM.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dpwm.c i2c.c i2s.c retarget.c sys.c uart.c
  group User
    ../: ConfigSysClk.h main.c readme.txt SysClk.c
