# IAR project USBD_UAC_85L40_PDMA.ewp, settings and files
configuration USBD_UAC_85L40_PDMA (ARM, debug)
  General.OGChipSelectEditMenu: I94000 series Nuvoton I94000 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\Include; ..\..\..\..\Library\Device\Nuvoton\I94100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_UAC_85L40_PDMA.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ./: startup_I94100.s
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c pdma.c retarget.c sys.c timer.c uart.c usbd.c
  group User
    ../: audio_desc.c AudioClass.c ConfigSysClk.h HIRC_AutoTrim.c main.c NAU85L40.c readme.txt SysClk.c
